/**
 * @file drag_models_complete.c
 * @brief Complete drag model implementation with all standard tables
 */

#include "drag_models_complete.h"
#include "ballistic_math.h"
#include <math.h>

// G1 Drag Table (Standard bullet - flat base with 2 caliber ogive)
static const drag_table_entry_t g1_table[] = {
    {0.00, 0.2629}, {0.05, 0.2558}, {0.10, 0.2487}, {0.15, 0.2413}, {0.20, 0.2344},
    {0.25, 0.2278}, {0.30, 0.2214}, {0.35, 0.2155}, {0.40, 0.2104}, {0.45, 0.2061},
    {0.50, 0.2032}, {0.55, 0.2020}, {0.60, 0.2034}, {0.65, 0.2165}, {0.70, 0.2230},
    {0.75, 0.2313}, {0.80, 0.2417}, {0.85, 0.2546}, {0.90, 0.2706}, {0.95, 0.2901},
    {1.00, 0.3136}, {1.05, 0.3415}, {1.10, 0.3734}, {1.15, 0.4084}, {1.20, 0.4448},
    {1.25, 0.4805}, {1.30, 0.5136}, {1.35, 0.5427}, {1.40, 0.5677}, {1.45, 0.5883},
    {1.50, 0.6053}, {1.55, 0.6191}, {1.60, 0.6393}, {1.65, 0.6518}, {1.70, 0.6589},
    {1.75, 0.6621}, {1.80, 0.6625}, {1.85, 0.6607}, {1.90, 0.6573}, {1.95, 0.6528},
    {2.00, 0.6474}, {2.05, 0.6413}, {2.10, 0.6347}, {2.15, 0.6280}, {2.20, 0.6210},
    {2.25, 0.6141}, {2.30, 0.6072}, {2.35, 0.6003}, {2.40, 0.5934}, {2.45, 0.5867},
    {2.50, 0.5804}, {2.60, 0.5685}, {2.70, 0.5573}, {2.80, 0.5467}, {2.90, 0.5368},
    {3.00, 0.5274}, {3.10, 0.5186}, {3.20, 0.5104}, {3.30, 0.5027}, {3.40, 0.4956},
    {3.50, 0.4889}, {3.60, 0.4827}, {3.70, 0.4768}, {3.80, 0.4713}, {3.90, 0.4662},
    {4.00, 0.4615}, {4.20, 0.4524}, {4.40, 0.4038}, {4.60, 0.4165}, {4.80, 0.4104},
    {5.00, 0.4061}
};

// G2 Drag Table (Aberdeen J projectile)
static const drag_table_entry_t g2_table[] = {
    {0.00, 0.2303}, {0.05, 0.2298}, {0.10, 0.2287}, {0.15, 0.2271}, {0.20, 0.2251},
    {0.25, 0.2227}, {0.30, 0.2196}, {0.35, 0.2156}, {0.40, 0.2107}, {0.45, 0.2048},
    {0.50, 0.1980}, {0.55, 0.1905}, {0.60, 0.1828}, {0.65, 0.1758}, {0.70, 0.1702},
    {0.75, 0.1669}, {0.80, 0.1664}, {0.85, 0.1690}, {0.90, 0.1754}, {0.95, 0.1865},
    {1.00, 0.2034}, {1.05, 0.2272}, {1.10, 0.2586}, {1.15, 0.2943}, {1.20, 0.3294},
    {1.25, 0.3611}, {1.30, 0.3892}, {1.35, 0.4132}, {1.40, 0.4334}, {1.45, 0.4501},
    {1.50, 0.4641}, {1.55, 0.4758}, {1.60, 0.4855}, {1.65, 0.4941}, {1.70, 0.5020},
    {1.75, 0.5089}, {1.80, 0.5150}, {1.85, 0.5206}, {1.90, 0.5258}, {1.95, 0.5306},
    {2.00, 0.5351}, {2.05, 0.5393}, {2.10, 0.5433}, {2.15, 0.5472}, {2.20, 0.5509},
    {2.25, 0.5546}, {2.30, 0.5581}, {2.35, 0.5615}, {2.40, 0.5649}, {2.45, 0.5682},
    {2.50, 0.5714}, {2.60, 0.5778}, {2.70, 0.5839}, {2.80, 0.5897}, {2.90, 0.5953},
    {3.00, 0.6007}, {3.10, 0.6057}, {3.20, 0.6105}, {3.30, 0.6149}, {3.40, 0.6191},
    {3.50, 0.6230}, {3.60, 0.6266}, {3.70, 0.6300}, {3.80, 0.6331}, {3.90, 0.6360},
    {4.00, 0.6387}, {4.20, 0.6434}, {4.40, 0.6475}, {4.60, 0.6509}, {4.80, 0.6537},
    {5.00, 0.6559}
};

// G5 Drag Table (Low-drag bullet)
static const drag_table_entry_t g5_table[] = {
    {0.00, 0.1710}, {0.05, 0.1719}, {0.10, 0.1727}, {0.15, 0.1732}, {0.20, 0.1734},
    {0.25, 0.1730}, {0.30, 0.1718}, {0.35, 0.1696}, {0.40, 0.1668}, {0.45, 0.1637},
    {0.50, 0.1603}, {0.55, 0.1566}, {0.60, 0.1529}, {0.65, 0.1497}, {0.70, 0.1473},
    {0.75, 0.1463}, {0.80, 0.1489}, {0.85, 0.1583}, {0.90, 0.1672}, {0.95, 0.1815},
    {1.00, 0.2051}, {1.05, 0.2413}, {1.10, 0.2884}, {1.15, 0.3379}, {1.20, 0.3785},
    {1.25, 0.4032}, {1.30, 0.4147}, {1.35, 0.4201}, {1.40, 0.4278}, {1.45, 0.4338},
    {1.50, 0.4373}, {1.55, 0.4392}, {1.60, 0.4403}, {1.65, 0.4406}, {1.70, 0.4401},
    {1.75, 0.4386}, {1.80, 0.4362}, {1.85, 0.4328}, {1.90, 0.4286}, {1.95, 0.4237},
    {2.00, 0.4182}, {2.05, 0.4121}, {2.10, 0.4057}, {2.15, 0.3991}, {2.20, 0.3926},
    {2.25, 0.3861}, {2.30, 0.3800}, {2.35, 0.3741}, {2.40, 0.3684}, {2.45, 0.3630},
    {2.50, 0.3578}, {2.60, 0.3481}, {2.70, 0.3393}, {2.80, 0.3314}, {2.90, 0.3243},
    {3.00, 0.3177}, {3.10, 0.3117}, {3.20, 0.3062}, {3.30, 0.3012}, {3.40, 0.2966},
    {3.50, 0.2923}, {3.60, 0.2884}, {3.70, 0.2847}, {3.80, 0.2813}, {3.90, 0.2782},
    {4.00, 0.2752}, {4.20, 0.2696}, {4.40, 0.2646}, {4.60, 0.2602}, {4.80, 0.2563},
    {5.00, 0.2528}
};

// G6 Drag Table (Flat base bullet)
static const drag_table_entry_t g6_table[] = {
    {0.00, 0.2617}, {0.05, 0.2553}, {0.10, 0.2491}, {0.15, 0.2432}, {0.20, 0.2376},
    {0.25, 0.2324}, {0.30, 0.2274}, {0.35, 0.2227}, {0.40, 0.2183}, {0.45, 0.2142},
    {0.50, 0.2104}, {0.55, 0.2069}, {0.60, 0.2039}, {0.65, 0.2013}, {0.70, 0.2013},
    {0.75, 0.2033}, {0.80, 0.2084}, {0.85, 0.2174}, {0.90, 0.2313}, {0.95, 0.2512},
    {1.00, 0.2779}, {1.05, 0.3122}, {1.10, 0.3548}, {1.15, 0.4056}, {1.20, 0.4643},
    {1.25, 0.5306}, {1.30, 0.6040}, {1.35, 0.6841}, {1.40, 0.7706}, {1.45, 0.8632},
    {1.50, 0.9615}, {1.55, 1.0653}, {1.60, 1.1743}, {1.65, 1.2883}, {1.70, 1.4070},
    {1.75, 1.5304}, {1.80, 1.6582}, {1.85, 1.7904}, {1.90, 1.9267}, {1.95, 2.0670},
    {2.00, 2.2112}, {2.05, 2.3591}, {2.10, 2.5106}, {2.15, 2.6556}, {2.20, 2.8540},
    {2.25, 3.0157}, {2.30, 3.1806}, {2.35, 3.3486}, {2.40, 3.5195}, {2.45, 3.6934},
    {2.50, 3.8703}, {2.60, 4.2364}, {2.70, 4.6181}, {2.80, 5.0152}, {2.90, 5.4275},
    {3.00, 5.8549}, {3.10, 6.2973}, {3.20, 6.7546}, {3.30, 7.2266}, {3.40, 7.7133},
    {3.50, 8.2145}, {3.60, 8.7302}, {3.70, 9.2602}, {3.80, 9.8044}, {3.90, 10.3626},
    {4.00, 10.9349}, {4.20, 12.1036}, {4.40, 13.3101}, {4.60, 14.5542}, {4.80, 15.8359},
    {5.00, 17.1551}
};

// G7 Drag Table (Long range VLD bullet)
static const drag_table_entry_t g7_table[] = {
    {0.00, 0.1198}, {0.05, 0.1197}, {0.10, 0.1196}, {0.15, 0.1194}, {0.20, 0.1193},
    {0.25, 0.1194}, {0.30, 0.1194}, {0.35, 0.1194}, {0.40, 0.1193}, {0.45, 0.1193},
    {0.50, 0.1194}, {0.55, 0.1193}, {0.60, 0.1194}, {0.65, 0.1197}, {0.70, 0.1202},
    {0.75, 0.1207}, {0.80, 0.1215}, {0.85, 0.1226}, {0.90, 0.1242}, {0.95, 0.1266},
    {1.00, 0.1306}, {1.05, 0.1368}, {1.10, 0.1464}, {1.15, 0.1660}, {1.20, 0.2054},
    {1.25, 0.2993}, {1.30, 0.3803}, {1.35, 0.4015}, {1.40, 0.4043}, {1.45, 0.4034},
    {1.50, 0.4014}, {1.55, 0.3987}, {1.60, 0.3955}, {1.65, 0.3884}, {1.70, 0.3814},
    {1.75, 0.3710}, {1.80, 0.3607}, {1.85, 0.3493}, {1.90, 0.3379}, {1.95, 0.3266},
    {2.00, 0.3156}, {2.05, 0.3049}, {2.10, 0.2943}, {2.15, 0.2841}, {2.20, 0.2742},
    {2.25, 0.2632}, {2.30, 0.2549}, {2.35, 0.2466}, {2.40, 0.2385}, {2.45, 0.2307},
    {2.50, 0.2232}, {2.60, 0.2090}, {2.70, 0.1967}, {2.80, 0.1859}, {2.90, 0.1763},
    {3.00, 0.1677}, {3.10, 0.1602}, {3.20, 0.1534}, {3.30, 0.1474}, {3.40, 0.1420},
    {3.50, 0.1372}, {3.60, 0.1330}, {3.70, 0.1292}, {3.80, 0.1258}, {3.90, 0.1227},
    {4.00, 0.1199}, {4.20, 0.1148}, {4.40, 0.1108}, {4.60, 0.1077}, {4.80, 0.1054},
    {5.00, 0.1037}
};

// G8 Drag Table (Short range bullet)
static const drag_table_entry_t g8_table[] = {
    {0.00, 0.2105}, {0.05, 0.2105}, {0.10, 0.2104}, {0.15, 0.2104}, {0.20, 0.2103},
    {0.25, 0.2103}, {0.30, 0.2103}, {0.35, 0.2103}, {0.40, 0.2103}, {0.45, 0.2102},
    {0.50, 0.2102}, {0.55, 0.2102}, {0.60, 0.2102}, {0.65, 0.2102}, {0.70, 0.2103},
    {0.75, 0.2103}, {0.80, 0.2104}, {0.85, 0.2104}, {0.90, 0.2105}, {0.95, 0.2106},
    {1.00, 0.2109}, {1.05, 0.2183}, {1.10, 0.2571}, {1.15, 0.3358}, {1.20, 0.4068},
    {1.25, 0.4378}, {1.30, 0.4476}, {1.35, 0.4493}, {1.40, 0.4477}, {1.45, 0.4450},
    {1.50, 0.4419}, {1.55, 0.4353}, {1.60, 0.4314}, {1.65, 0.4257}, {1.70, 0.4193},
    {1.75, 0.4129}, {1.80, 0.4068}, {1.85, 0.4008}, {1.90, 0.3953}, {1.95, 0.3900},
    {2.00, 0.3861}, {2.05, 0.3825}, {2.10, 0.3788}, {2.15, 0.3754}, {2.20, 0.3721},
    {2.25, 0.3686}, {2.30, 0.3657}, {2.35, 0.3630}, {2.40, 0.3603}, {2.45, 0.3575},
    {2.50, 0.3554}, {2.60, 0.3503}, {2.70, 0.3457}, {2.80, 0.3412}, {2.90, 0.3374},
    {3.00, 0.3336}, {3.10, 0.3303}, {3.20, 0.3269}, {3.30, 0.3239}, {3.40, 0.3209},
    {3.50, 0.3180}, {3.60, 0.3154}, {3.70, 0.3129}, {3.80, 0.3104}, {3.90, 0.3080},
    {4.00, 0.3058}, {4.20, 0.3015}, {4.40, 0.2983}, {4.60, 0.2960}, {4.80, 0.2945},
    {5.00, 0.2937}
};

// GI (Ingalls) Drag Table
static const drag_table_entry_t gi_table[] = {
    {0.00, 0.2629}, {0.05, 0.2558}, {0.10, 0.2487}, {0.15, 0.2413}, {0.20, 0.2344},
    {0.25, 0.2278}, {0.30, 0.2214}, {0.35, 0.2155}, {0.40, 0.2104}, {0.45, 0.2061},
    {0.50, 0.2032}, {0.55, 0.2020}, {0.60, 0.2034}, {0.65, 0.2165}, {0.70, 0.2230},
    {0.75, 0.2313}, {0.80, 0.2417}, {0.85, 0.2546}, {0.90, 0.2706}, {0.95, 0.2901},
    {1.00, 0.3136}, {1.05, 0.3415}, {1.10, 0.3734}, {1.15, 0.4084}, {1.20, 0.4448},
    {1.25, 0.4805}, {1.30, 0.5136}, {1.35, 0.5427}, {1.40, 0.5677}, {1.45, 0.5883},
    {1.50, 0.6053}, {1.55, 0.6191}, {1.60, 0.6393}, {1.65, 0.6518}, {1.70, 0.6589},
    {1.75, 0.6621}, {1.80, 0.6625}, {1.85, 0.6607}, {1.90, 0.6573}, {1.95, 0.6528},
    {2.00, 0.6474}, {2.05, 0.6413}, {2.10, 0.6347}, {2.15, 0.6280}, {2.20, 0.6210},
    {2.25, 0.6141}, {2.30, 0.6072}, {2.35, 0.6003}, {2.40, 0.5934}, {2.45, 0.5867},
    {2.50, 0.5804}, {2.60, 0.5685}, {2.70, 0.5573}, {2.80, 0.5467}, {2.90, 0.5368},
    {3.00, 0.5274}, {3.10, 0.5186}, {3.20, 0.5104}, {3.30, 0.5027}, {3.40, 0.4956},
    {3.50, 0.4889}, {3.60, 0.4827}, {3.70, 0.4768}, {3.80, 0.4713}, {3.90, 0.4662},
    {4.00, 0.4615}, {4.20, 0.4524}, {4.40, 0.4038}, {4.60, 0.4165}, {4.80, 0.4104},
    {5.00, 0.4061}
};

// Drag model definitions
static const drag_model_def_t drag_models[] = {
    {
        .type = DRAG_MODEL_G1,
        .table = g1_table,
        .table_size = sizeof(g1_table) / sizeof(g1_table[0]),
        .name = \"G1\",
        .description = \"Standard bullet - flat base with 2 caliber ogive\"
    },
    {
        .type = DRAG_MODEL_G2,
        .table = g2_table,
        .table_size = sizeof(g2_table) / sizeof(g2_table[0]),
        .name = \"G2\",
        .description = \"Aberdeen J projectile\"
    },
    {
        .type = DRAG_MODEL_G5,
        .table = g5_table,
        .table_size = sizeof(g5_table) / sizeof(g5_table[0]),
        .name = \"G5\",
        .description = \"Low-drag bullet\"
    },
    {
        .type = DRAG_MODEL_G6,
        .table = g6_table,
        .table_size = sizeof(g6_table) / sizeof(g6_table[0]),
        .name = \"G6\",
        .description = \"Flat base bullet\"
    },
    {
        .type = DRAG_MODEL_G7,
        .table = g7_table,
        .table_size = sizeof(g7_table) / sizeof(g7_table[0]),
        .name = \"G7\",
        .description = \"Long range VLD bullet\"
    },
    {
        .type = DRAG_MODEL_G8,
        .table = g8_table,
        .table_size = sizeof(g8_table) / sizeof(g8_table[0]),
        .name = \"G8\",
        .description = \"Short range bullet\"
    },
    {
        .type = DRAG_MODEL_GI,
        .table = gi_table,
        .table_size = sizeof(gi_table) / sizeof(gi_table[0]),
        .name = \"GI\",
        .description = \"Ingalls tables\"
    }
};

const drag_model_def_t* get_drag_model_def(drag_model_type_t type) {
    for (int i = 0; i < sizeof(drag_models) / sizeof(drag_models[0]); i++) {
        if (drag_models[i].type == type) {
            return &drag_models[i];
        }
    }
    return NULL;
}

float get_drag_coefficient_for_model(drag_model_type_t model_type, float mach) {
    const drag_model_def_t* model = get_drag_model_def(model_type);
    if (!model) {
        return 0.0f;
    }
    
    // Find bracketing points in the table
    const drag_table_entry_t* table = model->table;
    uint16_t size = model->table_size;
    
    // Below table range
    if (mach <= table[0].mach) {
        return table[0].cd;
    }
    
    // Above table range
    if (mach >= table[size - 1].mach) {
        return table[size - 1].cd;
    }
    
    // Interpolate within table
    for (int i = 0; i < size - 1; i++) {
        if (mach >= table[i].mach && mach <= table[i + 1].mach) {
            return ballistic_interpolate_linear(mach,
                                              table[i].mach, table[i].cd,
                                              table[i + 1].mach, table[i + 1].cd);
        }
    }
    
    // Fallback
    return table[0].cd;
}

// Approximate conversion ratios at transonic region (Mach 1.0)
static const float bc_conversion_ratios[][7] = {
    //       G1     G2     G5     G6     G7     G8     GI
    /*G1*/ {1.000, 1.365, 1.833, 0.839, 2.621, 1.249, 1.000},
    /*G2*/ {0.732, 1.000, 1.342, 0.614, 1.919, 0.914, 0.732},
    /*G5*/ {0.546, 0.745, 1.000, 0.458, 1.430, 0.681, 0.546},
    /*G6*/ {1.192, 1.628, 2.184, 1.000, 3.123, 1.488, 1.192},
    /*G7*/ {0.382, 0.521, 0.699, 0.320, 1.000, 0.476, 0.382},
    /*G8*/ {0.801, 1.094, 1.468, 0.672, 2.100, 1.000, 0.801},
    /*GI*/ {1.000, 1.365, 1.833, 0.839, 2.621, 1.249, 1.000}
};

static int get_model_index(drag_model_type_t model) {
    switch (model) {
        case DRAG_MODEL_G1: return 0;
        case DRAG_MODEL_G2: return 1;
        case DRAG_MODEL_G5: return 2;
        case DRAG_MODEL_G6: return 3;
        case DRAG_MODEL_G7: return 4;
        case DRAG_MODEL_G8: return 5;
        case DRAG_MODEL_GI: return 6;
        default: return 0;
    }
}

float convert_bc_between_models(float bc_value, 
                               drag_model_type_t from_model, 
                               drag_model_type_t to_model,
                               float mach) {
    if (from_model == to_model) {
        return bc_value;
    }
    
    int from_idx = get_model_index(from_model);
    int to_idx = get_model_index(to_model);
    
    float conversion_ratio = bc_conversion_ratios[from_idx][to_idx];
    
    // Apply mach-dependent correction (simplified)
    if (mach > 1.2f) {
        conversion_ratio *= 0.95f;  // Supersonic correction
    } else if (mach < 0.8f) {
        conversion_ratio *= 1.05f;  // Subsonic correction
    }
    
    return bc_value * conversion_ratio;
}

const drag_model_def_t** get_all_drag_models(uint8_t* count) {
    static const drag_model_def_t* model_list[7];
    
    for (int i = 0; i < 7; i++) {
        model_list[i] = &drag_models[i];
    }
    
    if (count) {
        *count = 7;
    }
    
    return model_list;
}
